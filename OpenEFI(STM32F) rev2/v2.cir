.title KiCad schematic
R7 VBAT ACC 15k
R8 GND VBAT 5k
IC8 GND GND GND GND SDA SCL Net-_IC8-Pad7_ /v2_1/5V1 24SN
SJ1 Net-_IC8-Pad7_ GND SJW
D27 GND VBAT 5.1v
SV1 GND NC_01 5V MA03-1
SV2 GND NC_02 5V MA03-1
SV3 GND GND M4 M3 M2 M1 ACC 5V FE08-1
SV4 NC_03 NC_04 NC_05 NC_06 NC_07 NC_08 NC_09 MA07-1
U$2 /v2_1/5V1 3V3 NC_10 GND GND GND A1 NC_11 NC_12 NC_13 NC_14 /v2_1/L5 D C NC_15 /v2_1/RX /v2_1/TX /v2_1/D- /v2_1/D+ NC_16 B A NC_17 NC_18 NC_19 NC_20 NC_21 NC_22 NC_23 SCL SDA NC_24 NC_25 NC_26 NC_27 NC_28 NC_29 NC_30 NC_31 NC_32 STM32F103C8T6-MODULE
Q2 Net-_Q2-PadB_ NC_33 GND BC548
R3 NC_34 Net-_Q2-PadB_ 1k
PROG1 GND /v2_1/TX /v2_1/RX Net-_D18-PadA_ MA04-1
D10 5V /v2_1/5V1 1N4148DO35-7
LED1 /v2_1/5V1 Net-_LED1-PadK_ LED3MM
LED2 /v2_1/5V1 Net-_LED2-PadK_ LED3MM
LED3 /v2_1/5V1 Net-_LED3-PadK_ LED3MM
LED4 /v2_1/5V1 Net-_LED4-PadK_ LED3MM
LED5 /v2_1/5V1 Net-_LED5-PadK_ LED3MM
R9 NC_35 Net-_LED1-PadK_ 1k
R10 NC_36 Net-_LED2-PadK_ 1k
R11 NC_37 Net-_LED3-PadK_ 1k
R12 NC_38 Net-_LED4-PadK_ 1k
R14 /v2_1/L5 Net-_LED5-PadK_ 1k
X1 NC_39 NC_40 NC_41 NC_42 NC_43 NC_44 NC_45 NC_46 NC_47 NC_48 NC_49 NC_50 NC_51 NC_52 NC_53 NC_54 NC_55 F15HP
X3 NC_56 NC_57 NC_58 NC_59 NC_60 NC_61 NC_62 NC_63 NC_64 NC_65 NC_66 NC_67 NC_68 NC_69 NC_70 NC_71 NC_72 F15HP
J1 RL1IN RL2IN RL3IN RL4IN RL5IN RL6IN 1053141206
J2 NC_73 NC_74 NC_75 NC_76 NC_77 NC_78 1053141206
D11 /v2_1/5V-USB /v2_1/5V1 1N4148DO35-7
X2 /v2_1/5V-USB /v2_1/D- /v2_1/D+ GND MINI-USB_4P-85-32004-10X
R15 NC_79 NC_80 1k
D18 Net-_D18-PadA_ /v2_1/5V1 1N4148DO35-7
P1 INY1 INY2 INY3 INY4 INY5 INY6 39-30-?06?
D2 GND GNC/GLP_MODE 5.1v
C1 GNC/GLP_MODE GND 0.1uf
IC3 A0 AOUT0 AOUT1 AOUT2 AOUT3 AOUT4 AOUT5 AOUT6 AOUT7 A B GND D C GND NC_81 NC_82 NC_83 NC_84 NC_85 VBAT LAMB1OUT LAMB0OUT 5V 4067D
DISPLAY1 GND 5V SDA SCL MA04-1
IC11 M2 M3 M4 RL1 RL2 RL3 RL4 GND Net-_IC11-Pad9_ GND /IO Principal/SCK2 /IO Principal/RCK GND NC_86 M1 5V 74595D
IC12 NC_87 NC_88 NC_89 NC_90 NC_91 NC_92 NC_93 GND NC_94 GND /IO Principal/SCK2 /IO Principal/RCK GND Net-_IC11-Pad9_ RL5 5V 74595D
P3 GND GND GND GND 39-30-?04?
F2 GND GND2 TE5
Q11 Net-_Q11-PadB_ ACC Net-_Q11-PadE_ BC548
Q12 Net-_Q11-PadB_ GND Net-_Q11-PadE_ BC558
Q3 Net-_Q3-PadB_ ACC Net-_Q3-PadE_ BC548
Q5 Net-_Q3-PadB_ GND Net-_Q3-PadE_ BC558
Q8 Net-_Q13-PadB_ ACC Net-_Q13-PadE_ BC548
Q13 Net-_Q13-PadB_ GND Net-_Q13-PadE_ BC558
Q18 Net-_Q18-PadB_ ACC Net-_Q18-PadE_ BC548
Q19 Net-_Q18-PadB_ GND Net-_Q18-PadE_ BC558
Q21 Net-_Q21-PadB_ ACC Net-_Q21-PadE_ BC548
Q22 Net-_Q21-PadB_ GND Net-_Q21-PadE_ BC558
Q24 Net-_Q24-PadB_ ACC Net-_Q24-PadE_ BC548
Q25 Net-_Q24-PadB_ GND Net-_Q24-PadE_ BC558
D25 GND INY1 BZY97
D1 GND INY2 BZY97
D4 GND INY3 BZY97
D6 GND INY4 BZY97
D7 GND INY5 BZY97
D16 GND INY6 BZY97
QP4 NC_95 INY4 GND2 IRLZ44N
QP2 NC_96 INY2 GND2 IRLZ44N
QP5 NC_97 INY5 GND2 IRLZ44N
QP3 NC_98 INY3 GND2 IRLZ44N
QP1 NC_99 INY1 GND2 IRLZ44N
QP6 NC_100 INY6 GND2 IRLZ44N
R31 NC_101 NC_102 R_Small
R33 NC_103 NC_104 R_Small
R43 NC_105 NC_106 R_Small
R45 NC_107 NC_108 R_Small
R46 NC_109 NC_110 R_Small
R44 NC_111 NC_112 R_Small
R47 NC_113 NC_114 R_Small
R48 NC_115 NC_116 R_Small
R32 NC_117 NC_118 R_Small
R34 NC_119 NC_120 R_Small
R16 RL1 Net-_Q26-PadB_ 1k
R17 RL2 Net-_Q9-PadB_ 1k
R20 RL3 Net-_Q10-PadB_ 1k
R23 RL4 Net-_Q15-PadB_ 1k
R21 RL5 Net-_Q16-PadB_ 1k
IC2 A1 A1 Net-_IC2-Pad3_ GND 3V3 LM358D
R1 A0 Net-_IC2-Pad3_ 2k
R2 GND Net-_IC2-Pad3_ 1k
Q26 Net-_Q26-PadB_ RL1IN GND BD139
Q9 Net-_Q9-PadB_ RL2IN GND BD139
Q10 Net-_Q10-PadB_ RL3IN GND BD139
Q15 Net-_Q15-PadB_ RL4IN GND BD139
Q16 Net-_Q16-PadB_ RL5IN GND BD139
R51 NC_121 Net-_Q4-PadB_ 1k
Q4 Net-_Q4-PadB_ RL6IN GND BD139
D9 GND RL1IN 1N4446
D12 GND RL2IN 1N4446
D13 NC_122 RL3IN 1N4446
D14 GND RL4IN 1N4446
D15 GND RL5IN 1N4446
D20 GND RL6IN 1N4446
C2 AIN0 GND 0.001uF
C7 AOUT0 GND C-EU025-025X050
D3 GND AOUT0 5.1v
R4 AOUT0 AIN0 R-US_0204_5
R5 5V AIN0 R-US_0204_5
C8 AIN1 GND 0.001uF
C9 AOUT1 GND C-EU025-025X050
D5 GND AOUT1 5.1v
R6 AOUT1 AIN1 R-US_0204_5
R13 5V AIN1 R-US_0204_5
C20 /Sensores/AIN3 GND 0.001uF
C21 AOUT3 GND C-EU025-025X050
D8 GND AOUT3 5.1v
R18 AOUT3 /Sensores/AIN3 R-US_0204_5
R19 5V /Sensores/AIN3 R-US_0204_5
C22 AIN4 GND 0.001uF
C23 AOUT4 GND C-EU025-025X050
D17 GND AOUT4 5.1v
R22 AOUT4 AIN4 R-US_0204_5
R24 5V AIN4 R-US_0204_5
C24 /Sensores/AIN2 GND 0.001uF
C25 AOUT2 GND C-EU025-025X050
D19 GND AOUT2 5.1v
R35 AOUT2 /Sensores/AIN2 R-US_0204_5
R36 5V /Sensores/AIN2 R-US_0204_5
C26 /Sensores/AIN5 GND 0.001uF
C27 AOUT5 GND C-EU025-025X050
D24 GND AOUT5 5.1v
R37 AOUT5 /Sensores/AIN5 R-US_0204_5
R38 5V /Sensores/AIN5 R-US_0204_5
C28 /Sensores/AIN6 GND 0.001uF
C29 AOUT6 GND C-EU025-025X050
D28 GND AOUT6 5.1v
R39 AOUT6 /Sensores/AIN6 R-US_0204_5
R40 5V /Sensores/AIN6 R-US_0204_5
C30 /Sensores/AIN7 GND 0.001uF
C31 AOUT7 GND C-EU025-025X050
D29 GND AOUT7 5.1v
R41 AOUT7 /Sensores/AIN7 R-US_0204_5
R42 5V /Sensores/AIN7 R-US_0204_5
IC9 LAMB0OUT Net-_IC9-Pad2_ Net-_C16-Pad1_ GND Net-_C18-Pad1_ Net-_IC9-Pad6_ LAMB1OUT 5V LM358D
C16 Net-_C16-Pad1_ GND 0.001uf
R25 NC_123 Net-_C16-Pad1_ 2k
C17 LAMB0OUT GND 0.22uf
R26 Net-_IC9-Pad2_ GND 1k
R27 Net-_IC9-Pad2_ LAMB0OUT 1.5k
C18 Net-_C18-Pad1_ GND 0.001uf
R28 NC_124 Net-_C18-Pad1_ 2k
C19 LAMB1OUT GND 0.22uf
R29 Net-_IC9-Pad6_ GND 1k
R30 Net-_IC9-Pad6_ LAMB1OUT 1.5k
.end
